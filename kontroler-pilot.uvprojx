# Keil uVision project kontroler-pilot.uvprojx, settings and files
target STM32F103RC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: kontroler-pilot
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\StdPeriph\inc;.\CMSIS\CoreSupport;.\CMSIS\DeviceSupport\ST\STM32F10x;.\src\buses;.\src\hardware;.\src\main;.\ExternalLibraries\Oled\delay;.\ExternalLibraries\Oled\IIC;.\ExternalLibraries\Oled\SPI;.\ExternalLibraries\Oled\SSD1306;.\ExternalLibraries\Oled\usher;.\src\adc;.\ExternalLibraries\nrf24;.\src\radio
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./src/main/: main.c main.h application_layer.h
  group hardware
    ./src/hardware/: hardware.c hardware.h
  group interfaces
    ./src/buses/: spi.c spi.h
  group adc
    ./src/adc/: adc.c adc.h
  group oled
    ./src/buses/: i2c.c i2c.h
  group ssd1306
    ./ExternalLibraries/Oled/delay/: delay.c delay.h
    ./ExternalLibraries/Oled/IIC/: IIC.c IIC.h
    ./ExternalLibraries/Oled/SSD1306/: Fonts.c Fonts.h SSD1306.c SSD1306.h
    ./ExternalLibraries/Oled/usher/: LIB_Config.h oledMain.c oledMain.h Config.c Config.h
  group radio
    ./src/radio/: radio.c radio.h commands.h commands.c
    ./ExternalLibraries/nrf24/: tm_stm32f4_nrf24l01.c tm_stm32f4_nrf24l01.h
  group StdPeriph
    ./StdPeriph/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./CMSIS/CoreSupport/: core_cm3.c
  group startup
    ./CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
